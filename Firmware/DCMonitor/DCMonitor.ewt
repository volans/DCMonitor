<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>FreeRTOS</name>
    <file>
      <name>$PROJ_DIR$\FreeRTOS\Source\portable\MemMang\heap_2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeRTOS\Source\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeRTOS\Source\portable\IAR\ARM_CM3\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeRTOS\Source\portable\IAR\ARM_CM3\portasm.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeRTOS\Source\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeRTOS\Source\tasks.c</name>
    </file>
  </group>
  <group>
    <name>FWLib</name>
    <group>
      <name>CMSIS</name>
      <group>
        <name>Startup</name>
        <file>
          <name>$PROJ_DIR$\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar\startup_stm32f10x_ld.s</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\Libraries\CMSIS\CM3\CoreSupport\core_cm3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\system_stm32f10x.c</name>
      </file>
    </group>
    <group>
      <name>Drivers</name>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
      </file>
    </group>
    <group>
      <name>USB</name>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32_USB-FS-Device_Driver\src\usb_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32_USB-FS-Device_Driver\src\usb_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32_USB-FS-Device_Driver\src\usb_int.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32_USB-FS-Device_Driver\src\usb_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32_USB-FS-Device_Driver\src\usb_regs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32_USB-FS-Device_Driver\src\usb_sil.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>Inc</name>
      <file>
        <name>$PROJ_DIR$\User\Inc\Analog_Hal.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\Inc\FreeRTOSConfig.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\Inc\hw_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\Inc\stm32f10x_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\Inc\stm32f10x_it.h</name>
      </file>
    </group>
    <group>
      <name>Src</name>
      <group>
        <name>USB</name>
        <file>
          <name>$PROJ_DIR$\User\Src\USB\usb_desc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\User\Src\USB\usb_endp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\User\Src\USB\usb_istr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\User\Src\USB\usb_prop.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\User\Src\USB\usb_pwr.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\User\Src\Analog_Hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\Src\hw_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\Src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\Src\stm32f10x_it.c</name>
      </file>
    </group>
  </group>
</project>


