# IAR project DCMonitor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x6 ST STM32F103x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_LD
  ICCARM.CCIncludePath2: Libraries\STM32F10x_StdPeriph_Driver\inc; User\Inc; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; FreeRTOS\Source\portable\IAR\ARM_CM3; FreeRTOS\Source\include; Libraries\STM32_USB-FS-Device_Driver\inc; User\Inc\Usb
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: User\Inc
  OBJCOPY.OOCOutputFile: DCMonitor.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group FreeRTOS
    FreeRTOS/Source/portable/MemMang/: heap_2.c
    FreeRTOS/Source/: list.c queue.c tasks.c
    FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group FWLib
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c
  group FWLib/CMSIS
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group FWLib/CMSIS/Startup
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_ld.s
  group FWLib/Drivers
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_usart.c
  group FWLib/USB
    Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User/Inc
    User/Inc/: Analog_Hal.h FreeRTOSConfig.h hw_config.h stm32f10x_conf.h stm32f10x_it.h
  group User/Src
    User/Src/: Analog_Hal.c hw_config.c main.c stm32f10x_it.c
  group User/Src/USB
    User/Src/USB/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
